# Keil uVision project bootloader.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bootloader +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,HSE_VALUE=8000000,__FPU_USED=0,USE_USB_OTG_FS
  c misc: --diag_suppress 177,550,1,1295 --gnu
  c include: ..\..\HAL\STM32F4\STMLib\STM32F4xx_StdPeriph_Driver;..\..\HAL\STM32F4\STMLib;..\..\HAL\Interface;..\..\HAL\STM32F4;..\..\;..\..\modules
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STMLib
    ../../HAL/STM32F4/STMLib/: startup_stm32f40_41xxx.s stm32f4xx_it.c system_stm32f4xx.c
    ../../HAL/STM32F4/STMLib/STM32F4xx_StdPeriph_Driver/: stm32f4xx_conf.h misc.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_gpio.c stm32f4xx_exti.c stm32f4xx_sdio.c stm32f4xx_tim.c
  group HAL&utils
    ../../HAL/STM32F4/: F4UART.cpp F4Storage.cpp F4SysTimer.cpp
    ../../modules/utils/: param.cpp space.cpp
  group bootloader
    ../../modules/bootloader/: bootloader.cpp
    ../../modules/utils/: ymodem.cpp
  group fat&sdcard
    ../../modules/FileSystem/: ff.c
    ../../HAL/STM32F4/: F4SDCard.c stm324xg_eval_sdio_sd.c stm324xg_eval.c
  group BSP_V4
    ../../BSP/boards/dev_v4/: RGBLED.cpp
