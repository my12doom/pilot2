# Keil uVision project bootloader401.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F401RBTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bootloader +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ./Output/bootloader/bootloader.bin ./Output/bootloader/bootloader.axf
  AfterMake: bin2h.exe Output/bootloader/bootloader.bin bootloader_data ../../modules/bootloader/bootloader_bin.h
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,HSE_VALUE=24000000,USE_USB_OTG_FS
  c misc: --diag_suppress 177,550,1,1295 --gnu
  c include: ..\..\HAL\STM32F4\STMLib\STM32F4xx_StdPeriph_Driver;..\..\HAL\STM32F4\STMLib;..\..\HAL\Interface;..\..\HAL\STM32F4;..\..\;..\..\modules
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STMLib
    ../../HAL/STM32F4/STMLib/STM32F4xx_StdPeriph_Driver/: stm32f4xx_conf.h misc.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_gpio.c stm32f4xx_exti.c stm32f4xx_sdio.c stm32f4xx_tim.c stm32f4xx_pwr.c
    ../../HAL/STM32F4/STMLib/: stm32f4xx_it.c system_stm32f4xx.c system_stm32f401.c startup_stm32f401.s
  group HAL&utils
    ../../HAL/STM32F4/: F4UART.cpp F4Storage.cpp F4SysTimer.cpp F4VCP.cpp
    ../../modules/utils/: param.cpp space.cpp AES.cpp RIJNDAEL.CPP
  group bootloader
    ../../modules/bootloader/: bootloader.cpp
    ../../modules/utils/: ymodem.cpp
  group fat&sdcard
    ../../modules/FileSystem/: ff.c
    ../../HAL/STM32F4/: F4SDCard.c stm324xg_eval_sdio_sd.c stm324xg_eval.c
  group BSP_V4
    ../../BSP/boards/dev_v4/: RGBLED.cpp
  group VCP
    ../../HAL/STM32F4/usb_comF4/cdc/: usbd_cdc_core.c usbd_cdc_vcp.c
    ../../HAL/STM32F4/usb_comF4/core/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../../HAL/STM32F4/usb_comF4/otg/: usb_core.c usb_dcd.c usb_dcd_int.c
    ../../HAL/STM32F4/usb_comF4/usb_conf/: usb_bsp.c usbd_desc.c usbd_usr.c
    ../../HAL/STM32F4/usb_comF4/: interrupt.c
