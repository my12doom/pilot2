# Keil uVision project F4SDR.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RC +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,HSE_VALUE=24000000,__FPU_USED=0,USE_USB_OTG_HS,USE_ULPI_PHY
  c misc: --diag_suppress 177,550,1,1295 --gnu
  c include: ..\..\HAL\STM32F4\STMLib\STM32F4xx_StdPeriph_Driver;..\..\HAL\STM32F4\STMLib;..\..\HAL\Interface;..\..\HAL\STM32F4;..\..\;..\..\modules
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STMLib
    ../../HAL/STM32F4/STMLib/: startup_stm32f40_41xxx.s system_stm32f4xx_24M.c
    ../../HAL/STM32F4/STMLib/STM32F4xx_StdPeriph_Driver/: stm32f4xx_conf.h misc.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_gpio.c stm32f4xx_exti.c stm32f4xx_sdio.c stm32f4xx_tim.c stm32f4xx_pwr.c stm32f4xx_spi.c
  group HAL&utils
    ../../HAL/STM32F4/: F4Storage.cpp F4SysTimer.cpp F4GPIO.cpp F4Interrupt.cpp F4SPI.cpp F4Timer.cpp F4HSBulk.cpp
    ../../HAL/Interface/: I2C_SW.cpp
    ../../modules/utils/: AES.cpp minilzo.c
  group utils
    ../../modules/main/: SWO.cpp
    ../../modules/utils/: space.cpp param.cpp log.cpp SEGGER_RTT.c
    ../../modules/FileSystem/: ff.c
    ../../HAL/STM32F4/: stm324xg_eval_sdio_sd.c stm324xg_eval.c F4SDCard.c
  group F4SDR
    ../../modules/F4SDR/: main.cpp fpga_config.cpp
    ../../HAL/aux_devices/: MAX2871.cpp ADF4351.cpp si5351.cpp
  group USB_HS
    ../../HAL/STM32F4/usbHSBulk/: usb_bsp.c usbd_core.c usbd_desc.c usbd_ioreq.c usbd_req.c usbd_usr.c usb_dcd_int.c usb_dcd.c usbd_cdc_core.c usb_core.c interrupt.c
