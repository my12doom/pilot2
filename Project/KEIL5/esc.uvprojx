# Keil uVision project esc.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SampleFirmware +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ./Output/Sample/sample.bin ./Output/Sample/SampleFirmware.axf
  AfterMake: BIn2Yap.exe output/Sample/sample.bin
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,HSE_VALUE=8000000,__FPU_USED=1,USE_USB_OTG_FS
  c misc: --diag_suppress 177,550,1,1295 --gnu
  c include: ..\..\HAL\STM32F4\STMLib\STM32F4xx_StdPeriph_Driver;..\..\HAL\STM32F4\STMLib;..\..\HAL\Interface;..\..\HAL\STM32F4;..\..\;..\..\modules
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ../../modules/main/: esc.cpp
  group STMLib
    ../../HAL/STM32F4/STMLib/: startup_stm32f40_41xxx.s stm32f4xx_it.c system_stm32f4xx_APP.c
    ../../HAL/STM32F4/STMLib/STM32F4xx_StdPeriph_Driver/: stm32f4xx_conf.h misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group HAL
    ../../HAL/Interface/: I2C_SW.cpp
    ../../HAL/STM32F4/: F4GPIO.cpp F4ADC.cpp F4UART.cpp F4SysTimer.cpp F4SPI.cpp F4Timer.cpp F4Storage.cpp F4SDCard.c stm324xg_eval.c stm324xg_eval_sdio_sd.c F4VCP.cpp F4Interrupt.cpp
  group Device
    ../../HAL/: Resources.cpp
    ../../HAL/sensors/: HMC5983SPI.cpp HMC5983SPI.h MPU6000.cpp MPU6000.h MS5611_SPI.cpp MS5611_SPI.h PX4Flow.cpp PX4Flow.h UartNMEAGPS.cpp UartNMEAGPS.h UartUbloxNMEAGPS.cpp Sonar.cpp PPMIN.cpp IST8307A.cpp
  group FileSystem
    ../../modules/FileSystem/: ff.c
  group NMEA
    ../../modules/NMEA/: context.c gmath.c info.c parse.c parser.c sentence.c time.c tok.c
  group usb_cdc_F4
    ../../HAL/STM32F4/usb_comF4/cdc/: usbd_cdc_core.c usbd_cdc_vcp.c
    ../../HAL/STM32F4/usb_comF4/core/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../../HAL/STM32F4/usb_comF4/otg/: usb_core.c usb_dcd.c usb_dcd_int.c
    ../../HAL/STM32F4/usb_comF4/usb_conf/: usb_bsp.c usbd_desc.c usbd_usr.c
    ../../HAL/STM32F4/usb_comF4/: interrupt.c
  group util
    ../../modules/utils/: param.cpp space.cpp log.cpp SEGGER_RTT.c
  group bsp_novatekv1
    ../../BSP/boards/novatek_v1/: AsyncWorker.cpp init.cpp RCOUT.cpp RGBLED.cpp TLC59208F.cpp
