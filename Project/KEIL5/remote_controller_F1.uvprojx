# Keil uVision project remote_controller_F1.uvprojx, settings and files
target rc_f1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: station +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER
  c misc: --diag_suppress 177,550,1,1295,1299,611 --gnu
  c include: ..\..\HAL\STM32F1\CMSIS;..\..\HAL\STM32F1\FWlib\;..\..\;..\..\modules
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group stm32
    ../../HAL/STM32F1/CMSIS/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
    ../../HAL/STM32F1/FWlib/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HAL
    ../../HAL/STM32F1/: F1GPIO.cpp F1SPI.cpp F1SysTimer.cpp F1Interrupt.cpp F1Timer.cpp F1UART.cpp F1Storage.cpp
    ../../HAL/sensors/: Sonar.cpp
  group util
    ../../modules/main/: SWO.cpp
    ../../modules/utils/: SEGGER_RTT.c RIJNDAEL.CPP space.cpp
    ../../HAL/aux_devices/: NRF24L01.cpp OLED_I2C.cpp
    ../../HAL/Interface/: I2C_SW.cpp
  group tx
    ../../modules/remote_controller/: tx.cpp
  group rx
    ../../modules/remote_controller/: rx.cpp
  group board
    ../../modules/remote_controller/: board_3288breakout_f1.cpp board_fsi6.cpp board_pi_rx.cpp PPMOUT_f1.cpp board_fsi6-2.cpp
