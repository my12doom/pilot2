# Keil uVision project ZLink.uvprojx, settings and files
target NODE (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F401RCTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ZLink +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ./Output/ZLink/ZLink.bin ./Output/ZLink/ZLink.axf
  AfterMake: BIn2Yap.exe output/ZLink/ZLink.bin
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,HSE_VALUE=24000000,USE_USB_OTG_FS
  c misc: --diag_suppress 177,550,1,1295 --gnu
  c include: ..\..\HAL\STM32F4\STMLib\STM32F4xx_StdPeriph_Driver;..\..\HAL\STM32F4\STMLib;..\..\HAL\Interface;..\..\HAL\STM32F4;..\..\;..\..\modules
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STMLib
    ../../HAL/STM32F4/STMLib/STM32F4xx_StdPeriph_Driver/: stm32f4xx_conf.h misc.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_gpio.c stm32f4xx_exti.c stm32f4xx_sdio.c stm32f4xx_tim.c stm32f4xx_pwr.c stm32f4xx_spi.c stm32f4xx_adc.c
    ../../HAL/STM32F4/STMLib/: system_stm32f401_APP.c startup_stm32f401.s
  group HAL&utils
    ../../HAL/STM32F4/: F4Storage.cpp F4SysTimer.cpp F4GPIO.cpp F4Interrupt.cpp F4SPI.cpp F4Timer.cpp F4VCP.cpp F4UART.cpp F4UART2.cpp
    ../../HAL/Interface/: I2C_SW.cpp
    ../../modules/main/: SWO.cpp
    ../../modules/utils/: AES.cpp
  group main
    ../../modules/ZLink/: ZLink.cpp ZLinkWireless.cpp RGBLED.cpp Station.cpp Node.cpp CompressedFile.cpp ZLinkWifi.cpp testLCD.cpp
    ../../modules/testZZ/: test2871.cpp
  group utils
    ../../modules/utils/: space.cpp param.cpp SEGGER_RTT.c SHA1.cpp minilzo.c
    ../../HAL/aux_devices/: SX127x.cpp SI4463.cpp si5351.cpp
  group VCP
    ../../HAL/STM32F4/usb_comF4/: interrupt.c
    ../../HAL/STM32F4/usb_comF4/cdc/: usbd_cdc_core.c usbd_cdc_vcp.c
    ../../HAL/STM32F4/usb_comF4/core/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../../HAL/STM32F4/usb_comF4/otg/: usb_core.c usb_dcd.c usb_dcd_int.c
    ../../HAL/STM32F4/usb_comF4/usb_conf/: usb_bsp.c usbd_desc.c usbd_usr.c
  group filesystem
    ../../HAL/STM32F4/: stm324xg_eval.c F4SDCard.c stm324xg_eval_sdio_sd.c
    ../../modules/FileSystem/: ff.c
  group esp_loader
    ../../modules/ZLink/esp-serial-flasher/: esp_loader.c md5_hash.c serial_comm.c port.cpp
target STATION (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F401RCTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: as above
  output: ZLink +hex
  AfterMake: as above
  AfterMake: BIn2Yap.exe output/ZLink/ZLink.bin
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: as above
  c misc: --diag_suppress 177,550,1,1295 --gnu
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
