# Keil uVision project scope.uvprojx, settings and files
target PD (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PD +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,HSE_VALUE=24000000,__FPU_USED=1,USE_USB_OTG_FS
  c misc: --diag_suppress 177,550,1,1295 --gnu
  c include: ..\..\HAL\STM32F4\STMLib\STM32F4xx_StdPeriph_Driver;..\..\HAL\STM32F4\STMLib;..\..\HAL\Interface;..\..\HAL\STM32F4;..\..\;..\..\modules;..\..\modules\FreeRTOS\Source\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group STMLib
    ../../HAL/STM32F4/STMLib/STM32F4xx_StdPeriph_Driver/: stm32f4xx_conf.h misc.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_gpio.c stm32f4xx_exti.c stm32f4xx_sdio.c stm32f4xx_tim.c stm32f4xx_pwr.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_spi.c
    ../../HAL/STM32F4/STMLib/: stm32f4xx_it.c startup_stm32f401.s system_stm32f401.c
  group HAL&utils
    ../../HAL/STM32F4/: F4UART.cpp F4UART2.cpp F4Storage.cpp F4SysTimer.cpp F4VCP.cpp F4GPIO.cpp F4Timer.cpp F4Interrupt.cpp F4SPI.cpp F4ADC.cpp
    ../../modules/utils/: param.cpp space.cpp RIJNDAEL.CPP SEGGER_RTT.c
    ../../HAL/aux_devices/: OLED_I2C.cpp LMX2572.cpp LMX2572.h MAX2871.cpp si5351.cpp
    ../../HAL/Interface/: I2C_SW.cpp
  group main
    ../../modules/scope/: PD.cpp SNA.cpp VNA.cpp GPSDO2.cpp LO.cpp adv7611.cpp adc.cpp
    ../../modules/main/: SWO.cpp
    ../../HAL/sensors/: UartUbloxNMEAGPS.cpp
  group fat&sdcard
    ../../modules/FileSystem/: ff.c
    ../../HAL/STM32F4/: F4SDCard.c stm324xg_eval_sdio_sd.c stm324xg_eval.c
  group BSP_V4
    ../../BSP/boards/dev_v4/: RGBLED.cpp
  group VCP
    ../../HAL/STM32F4/usb_comF4/cdc/: usbd_cdc_core.c usbd_cdc_vcp.c
    ../../HAL/STM32F4/usb_comF4/core/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../../HAL/STM32F4/usb_comF4/otg/: usb_core.c usb_dcd.c usb_dcd_int.c
    ../../HAL/STM32F4/usb_comF4/usb_conf/: usb_bsp.c usbd_desc.c usbd_usr.c
    ../../HAL/STM32F4/usb_comF4/: interrupt.c
  group adau1761
    ../../modules/scope/adau1761/: adau1761_mic_IC_1.cpp
target SNA (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: as above
  output: SNA +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: as above
  c misc: --diag_suppress 177,550,1,1295 --gnu
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target VNA (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: as above
  output: VNA +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: as above
  c misc: --diag_suppress 177,550,1,1295 --gnu
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target GPSDO2 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: as above
  output: scope +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: as above
  c misc: --diag_suppress 177,550,1,1295 --gnu
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target LO (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: as above
  output: LO +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: as above
  c misc: --diag_suppress 177,550,1,1295 --gnu
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target ADV7611 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: as above
  output: scope +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: as above
  c misc: --diag_suppress 177,550,1,1295 --gnu
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
