# Keil uVision project F0_FUSB302.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: spi +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER STM32F0XX
  c misc: --diag_suppress 177,550,1,1295,1299,611,1300 --gnu
  c include: ..\..\HAL\STM32F0\FWlib\;..\..\;..\..\modules
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group main
    ../../modules/FUSB302/: oled.cpp main.cpp main2.cpp
  group FWLib
    ../../HAL/STM32F0/FWlib/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
    ../../HAL/STM32F0/: startup_stm32f0xx.s system_stm32f0xx_48Mhz.c
  group HAL&util
    ../../HAL/STM32F0/: F0GPIO.cpp F0SysTimer.cpp
    ../../HAL/Interface/: I2C_SW.cpp
    ../../modules/utils/: SEGGER_RTT.c
software components: CMSIS:CORE 5.0.0
