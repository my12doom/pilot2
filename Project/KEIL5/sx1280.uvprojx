# Keil uVision project sx1280.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F401CBUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: sx1280 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,HSE_VALUE=8000000,USE_USB_OTG_FS
  c misc: --diag_suppress 177,550,1,1295 --gnu
  c include: ..\..\HAL\STM32F4\STMLib\STM32F4xx_StdPeriph_Driver;..\..\HAL\STM32F4\STMLib;..\..\HAL\Interface;..\..\HAL\STM32F4;..\..\;..\..\modules;..\..\modules\FreeRTOS\Source\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STMLib
    ../../HAL/STM32F4/STMLib/STM32F4xx_StdPeriph_Driver/: stm32f4xx_conf.h misc.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_gpio.c stm32f4xx_exti.c stm32f4xx_sdio.c stm32f4xx_tim.c stm32f4xx_pwr.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_spi.c
    ../../HAL/STM32F4/STMLib/: stm32f4xx_it.c startup_stm32f401.s system_stm32f401.c
  group HAL&utils
    ../../HAL/STM32F4/: F4UART.cpp F4Storage.cpp F4SysTimer.cpp F4GPIO.cpp F4Timer.cpp F4Interrupt.cpp F4SPI.cpp F4ADC.cpp
    ../../modules/utils/: param.cpp space.cpp RIJNDAEL.CPP SEGGER_RTT.c
    ../../HAL/aux_devices/: OLED_I2C.cpp
    ../../HAL/Interface/: I2C_SW.cpp
    ../../modules/main/: SWO.cpp
    ../../HAL/sensors/: MPU6000.cpp
  group sx1280_driver
    ../../modules/sx1280_sens/: test.cpp
    ../../modules/sx1280_sens/SX1280Lib/: sx1280.c sx1280-hal.c port.cpp
  group libsx1280
    ../../modules/sx1280_sens/libsx128x/lib/: sx1280.c sx1280-hal.c sx1280-radio.c
    ../../modules/sx1280_sens/: test2.cpp
    ../../modules/sx1280_sens/libsx128x/: port2.cpp
  group imu_heater
    ../../modules/sx1280_sens/: imu.cpp
