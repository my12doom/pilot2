# Keil uVision project sonarF1.uvprojx, settings and files
target SonarF1 (ARM-ADS)
  device: STM32F103T8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: station +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER
  c misc: --diag_suppress 177,550,1,1295,1299,611 --gnu
  c include: ..\..\HAL\STM32F1\CMSIS;..\..\HAL\STM32F1\FWlib\;..\..\;..\..\modules
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group stm32
    ../../HAL/STM32F1/CMSIS/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
    ../../HAL/STM32F1/FWlib/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HAL
    ../../HAL/STM32F1/: F1GPIO.cpp F1SPI.cpp F1SysTimer.cpp F1Interrupt.cpp
    ../../HAL/sensors/: Sonar.cpp
    ../../modules/main/: SWO.cpp
  group main
    ../../modules/utils/: SEGGER_RTT.c SEGGER_RTT_Printf.c
    ../../modules/main/: sonarF1.cpp
