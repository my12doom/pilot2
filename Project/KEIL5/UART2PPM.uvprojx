# Keil uVision project UART2PPM.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PPM +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ./Output/bootloader/bootloader.bin ./Output/bootloader/bootloader.axf
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,HSE_VALUE=8000000,__FPU_USED=0,USE_USB_OTG_FS
  c misc: --diag_suppress 177,550,1,1295 --gnu
  c include: ..\..\HAL\STM32F4\STMLib\STM32F4xx_StdPeriph_Driver;..\..\HAL\STM32F4\STMLib;..\..\HAL\Interface;..\..\HAL\STM32F4;..\..\;..\..\modules
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STMLib
    ../../HAL/STM32F4/STMLib/: startup_stm32f40_41xxx.s stm32f4xx_it.c system_stm32f4xx.c
    ../../HAL/STM32F4/STMLib/STM32F4xx_StdPeriph_Driver/: stm32f4xx_conf.h misc.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_gpio.c stm32f4xx_exti.c stm32f4xx_sdio.c stm32f4xx_tim.c stm32f4xx_pwr.c
  group HAL&utils
    ../../HAL/STM32F4/: F4UART.cpp F4Storage.cpp F4SysTimer.cpp F4GPIO.cpp
    ../../modules/utils/: param.cpp space.cpp
  group UART2PPM
    ../../modules/UART2PPM/: uart2ppm.cpp PPMOUT.cpp
    ../../BSP/boards/mo_v3/: RCOUT.cpp
    ../../HAL/sensors/: PPMIN.cpp
    ../../HAL/STM32F4/: F4Interrupt.cpp
